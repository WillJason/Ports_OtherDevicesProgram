# Keil uVision project project.uvproj, settings and files
target target (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: JXKJ-zdn +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group source
    ./: STARTUP.A51
    ./src/: iap.c timer.c uart.c yx5200.c Ps2_Int.c beep.c
  group user
    ./src/: global.c main.c
